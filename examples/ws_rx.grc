options:
  parameters:
    author: l1berat0r
    generate_options: qt_gui
    id: new_ws
    output_language: python
    title: Weatherstation
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '-500e3'
    low_cutoff_freq: '-700e3'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 1e4
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 2.5e6
    ch_align: 'False'
    channel_mode: '0'
    gain_dB_ch0: '30'
    oversample: '0'
    rf_freq: 434.5e6
    samp_rate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_HAMMING
  states: {state: disabled}
- name: weatherstation_decode_ws_0
  id: weatherstation_decode_ws
  parameters:
    debug: 'True'
    sample_rate: '2500000'
    threshold: '0.3'
  states: {}
- name: weatherstation_wspanel_0
  id: weatherstation_wspanel
  parameters:
    debug: 'False'
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', band_pass_filter_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0, '0', weatherstation_decode_ws_0, '0']
- [limesdr_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [weatherstation_decode_ws_0, out, weatherstation_wspanel_0, in]

metadata:
  file_format: 1
