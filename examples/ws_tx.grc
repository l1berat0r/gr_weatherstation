options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 417e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 500e3
    low_cutoff_freq: 400e3
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 1e4
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '40'
    gain_dB_ch1: '30'
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: 433.5e6
    samp_rate: samp_rate
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 5e6
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    ch_align: 'False'
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '30'
    gain_dB_ch1: '30'
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: 433.5e6
    samp_rate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: weatherstation_decode_ws_0_0
  id: weatherstation_decode_ws
  parameters:
    debug: 'True'
    sample_rate: '2500000'
    threshold: '0.150'
  states: {}
- name: weatherstation_encode_ws_0
  id: weatherstation_encode_ws
  parameters:
    debug: 'False'
    pulse_length_ms: '0.5'
    sample_rate: '2500000'
  states: {}
- name: weatherstation_wspanel_0
  id: weatherstation_wspanel
  parameters:
    debug: 'True'
  states: {}
- name: weatherstation_wspanel_tx_0
  id: weatherstation_wspanel_tx
  parameters: {}
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '1']
- [band_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_complex_to_mag_0, '0', weatherstation_decode_ws_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', limesdr_sink_0, '0']
- [limesdr_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [limesdr_source_0, '0', qtgui_sink_x_0, '0']
- [weatherstation_decode_ws_0_0, out, weatherstation_wspanel_0, in]
- [weatherstation_encode_ws_0, '0', blocks_float_to_complex_0, '0']
- [weatherstation_wspanel_tx_0, out, weatherstation_encode_ws_0, in]

metadata:
  file_format: 1
